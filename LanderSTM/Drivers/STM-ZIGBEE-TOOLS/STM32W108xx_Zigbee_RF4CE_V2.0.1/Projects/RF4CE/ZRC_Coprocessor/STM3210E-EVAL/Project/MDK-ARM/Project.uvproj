# Keil uVision project Project.uvproj, settings and files
target nwkCop10EEval_UART (ARM-ADS)
  device: STM32F103RG STMicroelectronics
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: nwkCop10EEval_UART
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD,USE_STM3210E_EVAL,APPLICATION_HAS_COMMAND_ERROR_HANDLER,
  c misc: --C99
  c include: .\..\;.\..\inc;.\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;.\..\..\Utilities\STM32_EVAL;.\..\..\Utilities\STM32_EVAL\Common;.\..\..\Utilities\STM32_EVAL\STM3210E_EVAL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group CMSIS
    ./../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group MDK-ARM
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group StdPeriph_Driver
    ./../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_exti.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_usart.c
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_dma.c stm32f10x_i2c.c stm32f10x_sdio.c
  group STM32_EVAL
    ./../../Utilities/STM32_EVAL/: stm32_eval.c
  group User
    ./../src/: cerc_rf4ce.c rf4ce_cmds.c serial_utils.c stm32_sc.c stm32f10x_it.c stRC.c
target nwkCop10EEval_SPI (ARM-ADS)
  device: STM32F103RG STMicroelectronics
  cpu: as above
  output: nwkCop10EEval_SPI
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD,USE_STM3210E_EVAL,SC_SPI,APPLICATION_HAS_COMMAND_ERROR_HANDLER,
  c misc: --C99
  c include: .\..\;.\..\inc;.\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;.\..\..\Utilities\STM32_EVAL;.\..\..\Utilities\STM32_EVAL\Common;.\..\..\Utilities\STM32_EVAL\STM3210B_EVAL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
